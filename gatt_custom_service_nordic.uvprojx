# Keil uVision project gatt_custom_service_nordic.uvprojx, settings and files
target nRF51422 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: gatt_custom_service_nordic +hex
  c flags: Optim=4 OneElfS=1
  c define: BOARD_PCA10028 BLE_STACK_SUPPORT_REQD
  c misc: --c99
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ./: main.c
  group Timer Handler
    ./: timer_handler.c
  group UART Handler
    ./: uart_handler.c
software components: CMSIS:CORE 4.1.0, Board Support:bsp 8.1.1, Device:Startup 8.0.3, nRF_BLE:BLE_Modules:ble_advdata 3.0.0, nRF_BLE:BLE_Modules:ble_common 3.0.0, nRF_BLE:BLE_Modules:ble_conn_params 3.0.0, nRF_BLE:BLE_Modules:ble_service_common 3.0.0, nRF_Drivers:app_uart 3.0.0, nRF_Drivers:nrf_delay 3.0.0, nRF_Drivers:nrf_drv_common 3.0.0, nRF_Drivers:nrf_drv_gpiote 3.0.0, nRF_Drivers:nrf_error 3.0.0, nRF_Drivers:nrf_gpio 3.0.0, nRF_Drivers:nrf_gpiote 3.0.0, nRF_Drivers:nrf_timer 3.0.0, nRF_Libraries:app_button 3.0.0, nRF_Libraries:app_error 3.0.0, nRF_Libraries:app_fifo 3.0.0, nRF_Libraries:app_timer 3.0.0, nRF_Libraries:app_util 3.0.0, nRF_Libraries:nordic_common 3.0.0, nRF_Libraries:nrf_assert 3.0.0, nRF_Libraries:retarget 3.0.0, nRF_SoftDevice:Internal:sd_common 1.1.3, nRF_SoftDevice:Internal:softdevice_present 1.1.3, nRF_SoftDevice:s110 8.0.1
